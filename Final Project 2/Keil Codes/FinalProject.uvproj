# Keil uVision project FinalProject.uvproj, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: LPC1114/102 NXP
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: FinalProject
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./: ADC.c ADC.h keypad_scanner.c keypad_scanner.h LCD_driver.c LCD_driver.h main.c UART.c UART.h timer.c timer.h startup_LPC11xx.s
